# IAR project STM8_StepMotorTester.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCIncludePath2: src; lib; lib\inc; lib\src
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: STM8_StepMotorTester.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.cpp main.hpp
  group Src
    Src/: adc.cpp adc.hpp i2c.cpp i2c.hpp keys.cpp keys.hpp menu.cpp menu.hpp OLED_F103F3.cpp OLED_F103F3.hpp soft_timers.cpp soft_timers.hpp
